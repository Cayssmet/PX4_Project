## firmware/esp32_pos_tx/sdkconfig.defaults
```kconfig
# 目标芯片：ESP32-S3（只支持 2.4 GHz WiFi）
# sdkconfig 本身不入库（见 .gitignore），首次编译会由本文件生成
CONFIG_IDF_TARGET="esp32s3"
```
